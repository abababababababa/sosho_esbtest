#include "sosho_R.dtsi"

&spi1 { status = "okay"; };
&trackball { status = "okay"; };

// R側トラックボール（reg = 3）へ接続
&trackball_split_R {
    status = "okay";
    device = <&trackball>;
};